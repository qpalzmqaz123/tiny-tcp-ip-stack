# Keil uVision project test.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F401RE STMicroelectronics
  cpu: IROM(0x08000000,0x60000) IRAM(0x20000000,0x18000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: test
  c flags: Optim=4 OneElfS=1
  c define: USE_STDPERIPH_DRIVER
  c include: ..\lib\inc;..\other;..\Third\fatfs;..\user;..\webserver\tcp_ip;..\TCP_IP_Stack;..\TCP_IP_Stack\internet_layer;..\TCP_IP_Stack\network_layer;..\TCP_IP_Stack\transport_layer;..\webserver
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x60000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group startup
    ./: startup_stm32f4xx.s
  group user
    ../user/: main.c stm32f4xx_it.c system_stm32f4xx.c
  group fat
    ../Third/fatfs/: diskio.c ff.c
    ../Third/fatfs/option/: ccsbcs.c
  group other
    ../other/: sdio_sd.c spi.c usart.c
  group lib
    ../lib/src/: misc.c stm32f4xx_dma.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_sdio.c stm32f4xx_usart.c stm32f4xx_spi.c
  group webserver
    ../webserver/: http.c webserver.c ftp.c
  group TCP_IP_Stack
    ../TCP_IP_Stack/internet_layer/: IP.c ARP.c ICMP.c
    ../TCP_IP_Stack/network_layer/: enc28j60.c spi_enc28j60.c eth.c driver.c TCP_virtualWindow.c
    ../TCP_IP_Stack/transport_layer/: TCP.c UDP.c
    ../TCP_IP_Stack/: share.c myTCPIP.c
